# Use GStreamer 0.10 instead of GStreamer 1.0

PACKAGECONFIG = "gstreamer010 qtlocation qtmultimedia qtsensors"
