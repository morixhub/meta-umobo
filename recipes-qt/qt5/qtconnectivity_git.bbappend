# Remove bluez
PACKAGECONFIG[bluez] = ","

# Customize package config content
PACKAGECONFIG_remove = "bluez"





