PACKAGECONFIG_append = " gstreamer "





